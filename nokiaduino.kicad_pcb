# Repository llegoff/nokiaduino

File README.md:

nokiaduino
==========
carte compatible Arduino équipée d'un afficheur de nokia 5110 , 
un clavier 5 touches, un lecteur de carte microSD, un convertisseur DC-DC boost
et des connecteur pour ajouter des capteurs.

*Arduino compatible board provided with a display of nokia 5110,
5 keys keyboard, a microSD card slot, a DC-DC boost converter
and connector to add sensors.*

Schemas
-------

PCB
---

## KiCad design nokiaduino.kicad_pcb

Parts:
BT1: 2x1v5
C1, C2: 22p
C3, C4, C13: 100n
C5, C7: 47u
C6: 100u
C8, C9, C10, C11, C12: 470n
D1: 1N5819
IC1: ATMEGA328P; TQFP32
IC2: BL8530-50
IC3: 4050
IC4: AP1117-E33
JP1: Without BL8530
JP2: Whitout AP1117
L1: 47u
LED1: LED RGB
LOGO1: OPEN_HARDWARE_1
P1: lcd nokia
P2: Adafruit5110
P3: COM
P4: D3
P5: D5
P6: D6
P7: A2
P8: A3
P9: I2C
P10: ISP
P11: USD_CARD
P12: USB-MINI-B
R1: 10k
R2: 100
R3, R4, R5: 680
SW1: A0
SW2: A1
SW3: D2
SW4: D4
SW5: D7
SW6: SW_PUSH
SW7: SWITCH_INV
SW'1, SW'2, SW'3, SW'4, SW'5: SW_PUSH
X1: 16mhz

Connections:
+3.3V: C7.1, IC3.1 (VCC), IC4.2 (VOUT), JP2.2, P1.6, P2.2, P11.4
+5V: C6.1, C13.1, D1.2 (K), IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC2.2 (VOUT), IC4.3 (VIN), JP1.2, JP2.1, P3.3, P4.2 (PM), P5.2 (PM), P6.2 (PM), P7.2 (PM), P8.2 (PM), P9.2, P10.2, P12.1 (VBUS), R1.1
/0: IC1.30 ((PCINT16/RXD)PD0), P3.4
/1: IC1.31 ((PCINT17/TXD)PD1), P3.5
/2: C10.1, IC1.32 ((PCINT18/INT0)PD2), SW3.1, SW'3.1
/3: IC1.1 ((PCINT19/OC2B/INT1)PD3), P4.3, R5.1
/4: C11.1, IC1.2 ((PCINT20/XCK/T0)PD4), SW4.1, SW'4.1
/5: IC1.9 ((PCINT21/OC0B/T1)PD5), P5.3, R4.1
/6: IC1.10 ((PCINT22/OC0A/AIN0)PD6), IC3.14, P6.3, R3.1
/6': IC3.15, P11.2
/7: C12.1, IC1.11 ((PCINT23/AIN1)PD7), SW5.1, SW'5.1
/8: IC1.12 ((PCINT0/CLKO/ICP1)PB0), IC3.7
/8': IC3.6, P1.3, P2.5
/9: IC1.13 ((PCINT1/OC1A)PB1), IC3.3
/9': IC3.2, P1.1, P2.7
/10: IC1.14 ((PCINT2/OC1B/~SS~)PB2), IC3.5
/10': IC3.4, P1.2, P2.6
/A0: C8.1, IC1.23 ((PCINT8/ADC0)PC0), SW1.1, SW'1.1
/A1: C9.1, IC1.24 ((PCINT9/ADC1)PC1), SW2.1, SW'2.1
/A2: IC1.25 ((PCINT10/ADC2)PC2), P7.3
/A3: IC1.26 ((PCINT11/ADC3)PC3), P8.3
/A4: IC1.27 ((PCINT12/SDA/ADC4)PC4), P9.4
/A5: IC1.28 ((PCINT14/SCL/ADC5)PC5), P9.3
/A6: IC1.19 (ADC6), R2.2
/A7: BT1.1 (+), IC1.22 (ADC7), SW7.3
/MISO: IC1.16 ((PCINT4/MISO)PB4), P10.1, P11.7
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), IC3.9, P10.4
/MOSI': IC3.10, P1.4, P2.4, P11.3
/OSC1: C1.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
/OSC2: C2.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
/Reset: C4.1, IC1.29 ((PCINT14/~RESET~)PC6), P10.5, R1.2, SW6.2
/SCK: IC1.17 ((PCINT5/SCK)PB5), IC3.11, P10.3
/SCK': IC3.12, P1.5, P2.3, P11.5
GND: BT1.2 (-), C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), IC2.1 (GND), IC3.8 (VSS), IC4.1 (ADJ/GND), LED1.1 (KB), LED1.2 (KG), LED1.3 (KR), P1.8, P2.1, P3.1, P3.2, P4.1, P5.1, P6.1, P7.1, P8.1, P9.1, P10.6, P11.6, P12.5 (GND), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.1, SW'1.2, SW'2.2, SW'3.2, SW'4.2, SW'5.2
unnamed: C5.1, JP1.1, L1.1, SW7.2
unnamed: C4.2, P3.6
unnamed: D1.1 (A), IC2.3 (LX), L1.2
unnamed: LED1.5 (AG), R4.2
unnamed: LED1.6 (AB), R3.2
unnamed: LED1.4 (AR), R5.2
unnamed: C3.1, IC1.20 (AREF)
unnamed: P1.7, P2.8, R2.1

Board: 2 copper layers, 57 parts (0 on the bottom side), 42 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3: P***; 1pin

## Commit log

2014-09-11 :neckbeard: Added .gitattributes & .gitignore files
2014-09-13 images pcb
